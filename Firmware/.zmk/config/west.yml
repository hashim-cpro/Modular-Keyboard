## Firmware/ZMK/boards/shields/id1/Kconfig.defconfig
```kconfig
if SHIELD_ID1

config ZMK_KEYBOARD_NAME
    default "modular keyboard"

endif # SHIELD_ID1
```
